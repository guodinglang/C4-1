# Keil uVision project project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F415KBU7-4 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.8
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER,AT_START_F415_V1
  c include: ..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\..\libraries\cmsis\cm4;..\..\libraries\cmsis\dsp\ComputeLibrary;..\..\libraries\cmsis\dsp\include;..\..\libraries\cmsis\dsp\PrivateInclude;..\..\libraries\cmsis\dsp\Source;..\..\libraries\cmsis\dsp;..\..\libraries\drivers\inc;..\..\libraries\drivers\src;..\..\libraries\drivers;..\bsp\inc;..\bsp\src;..\bsp
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ../bsp/src/: at32f415_clock.c at32f415_int.c main.c
  group bsp
    ../bsp/src/: Initial.c IOstream.c SerialPort.c Command.c flash.c SPIdrive.c Function.c AD5504.c chokeDelay.c
  group library
    ../../libraries/drivers/src/: at32f415_adc.c at32f415_can.c at32f415_cmp.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_ertc.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f415.s
